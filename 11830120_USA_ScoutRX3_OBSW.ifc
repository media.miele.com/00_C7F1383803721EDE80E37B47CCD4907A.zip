Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-06-01T14:47:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 01 14:47:22 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7dfda3d2-5f22-41ae-b6ed-96053ea60e0f\9fc7f63f-b2c3-47c5-8c93-8d4d64ac65af\ifc * Database version: 5507 * Database creation date: Thu Jun 01 14:47:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 01 14:47:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 01 14:47:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11830120_USA_ScoutRX3_OBSW:41PQL005_USA_11830120_ScoutRX3_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 41PQL005_USA_11830120_ScoutRX3_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 41PQL005_USA_11830120_ScoutRX3_OBSW
Material: z_Miele_Design_CLST, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
